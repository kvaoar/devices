# Keil uVision project scintillator2.uvprojx, settings and files
target scintillator2 Configuration (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: scintillator2 Configuration
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --C99
  c include: ../Inc;                                                                     ../Drivers/STM32F1xx_HAL_Driver/Inc;                                                                     ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                                                     ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                                     ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Inc;                                                                     ../Drivers/CMSIS/Include;                                                                     ../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_flash.c stm32f1xx_hal_pwr.c stm32f1xx_hal_rcc.c stm32f1xx_hal_flash_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_cortex.c stm32f1xx_hal_dma.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_adc.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_tim.c
  group Application/User
    ../Src/: stm32f1xx_it.c usb_device.c main.c stm32f1xx_hal_msp.c usbd_conf.c usbd_cdc_if.c usbd_desc.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Class/CDC/Src/: usbd_cdc.c
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ioreq.c usbd_ctlreq.c
  group Application/MDK-ARM
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/arm/: startup_stm32f103xb.s
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32F1xx/Source/Templates/: system_stm32f1xx.c
  group ::CMSIS Driver
    D:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/2.0.0/RTE_Driver/: USART_STM32F10x.c
  group ::Device
    D:/Keil5/ARM/PACK/Keil/STM32F1xx_DFP/2.0.0/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
    RTE/Device/STM32F103C8/: RTE_Device.h startup_stm32f10x_md.s system_stm32f10x.c
software components: CMSIS:CORE 3.30.0, CMSIS Driver:USART 2.0, Device:DMA 1.2, Device:GPIO 1.2, Device:Startup 1.0.0
